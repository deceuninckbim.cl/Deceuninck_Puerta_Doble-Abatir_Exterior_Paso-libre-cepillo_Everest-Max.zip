Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-26T09:54:10
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 26 09:54:10 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\792897df-17cf-4808-9be0-231cc600ccb6\91cb548e-96bd-4d14-b35e-19092eee2d4c\ifc * Database version: 5507 * Database creation date: Tue Dec 26 09:54:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 26 09:54:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 26 09:54:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max:Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max, Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max:Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max:616887
In: Level 1
Type - Classification: B2030100 Glazed Doors & Entrances (Uniformat); Material: PVC, Deceuninck - 1.White/PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Glass Height: 1974 mm; Glass Width: 1752 mm; Height: 2200 mm; Max. Height: 2300 mm; Max. Width: 2000 mm; Rough Height: 2158.5 mm; Sash Fit: 34 mm; Span Height: 2210 mm; Span Width: 2010 mm; Width: 2000 mm
Type - Identity Data - Assembly Code: B2030100; Assembly Description: Glazed Doors & Entrances; Constructive depth: 60mm; C-Section Model: https://skfb.ly/oFvNZ; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 - 36mm; International Certification: ISO 9001-ISO 14001-ISO 18001 approved by TUV Rheiland; Line: Everest Max; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Free passage doble casement door with brush; NOTE*: Consider corner joint profile 11644; OmniClass Number: 23.30.10.00; OmniClass Title: Doors; Opening: Exterior; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 78; Type Name: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max; URL: www.deceuninck.cl
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Everest-max-puerta-doble-abatir-cepillo.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Model Properties - Acoustic insulation: Rw = 33 (-1; -4)dB (ISO 140-3, ISO 717); Air permeability: CLASS 4 - EN14351-1+A1; Fire reaction: Class C-s3, d2 according to EN 13501-1; Water tightness: CLASS 9A - EN14351-1+A1; Wind load resistance: CLASS C1/B2 - EN14351-1+A1
Type - Other - Category: Doors; Family Name: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max
Type - Structural - Includes reinforcement: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Doors
Type - Pset_ProvisionForVoid - Width: 2000 mm; Height: 2200 mm
Material: Glass, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 9.42737 m2; Volume: 0.0922721 m3
Identity Data - Mark: 55
Other - Family: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max; Family and Type: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max; Head Height: 2200 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max; Type Id: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max: Deceuninck_Puerta_Doble-Abatir-Exterior_Paso-libre-cepillo_Everest-Max
Phasing - Phase Created: New Construction
